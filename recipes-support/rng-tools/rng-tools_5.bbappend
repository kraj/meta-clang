FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://When-adding-entropy-allocate-the-struct-dynamically.patch"
