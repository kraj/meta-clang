CFLAGS_append_x86-64 = " -fheinous-gnu-extensions "
