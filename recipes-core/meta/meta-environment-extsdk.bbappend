FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

require clang-environment.inc
