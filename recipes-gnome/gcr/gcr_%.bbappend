# qemu crashes when built with hardening flags
#
GI_DATA_ENABLED_toolchain-clang = "False"

