RDEPENDS:${PN}:append:toolchain-clang = " clang-libllvm"
