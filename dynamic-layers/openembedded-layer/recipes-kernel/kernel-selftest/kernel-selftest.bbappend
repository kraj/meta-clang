DEPENDS_append = " clang-native"
DEPENDS_remove = "llvm-native"
