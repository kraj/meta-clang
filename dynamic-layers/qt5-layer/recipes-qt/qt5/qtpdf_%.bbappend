# its needed to build gn-native which is embedded into
# qtpdf directly

TOOLCHAIN_NATIVE = "clang"
