inherit toolchain/clang-native
