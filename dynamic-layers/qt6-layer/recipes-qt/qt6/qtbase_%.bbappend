PACKAGECONFIG_DEFAULT:append:toolchain-clang = " use-lld-linker"
