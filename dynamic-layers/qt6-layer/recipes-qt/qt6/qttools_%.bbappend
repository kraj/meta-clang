PACKAGECONFIG:append = " clang"
