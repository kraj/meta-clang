FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append += " file://fix_duplicate_main.patch "
