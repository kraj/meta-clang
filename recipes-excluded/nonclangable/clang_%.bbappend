TOOLCHAIN_class-native = "gcc"
