# see https://bugs.llvm.org/show_bug.cgi?id=34674
TUNE_CCARGS_remove_aarch64 = "-no-integrated-as"
TUNE_CCARGS_remove_aarch64_be = "-no-integrated-as"

