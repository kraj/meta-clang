FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

inherit toolchain/clang-native

