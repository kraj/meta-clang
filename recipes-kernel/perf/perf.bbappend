DEPENDS_append_toolchain-clang_class-target = " clang-cross-${TARGET_ARCH}"
