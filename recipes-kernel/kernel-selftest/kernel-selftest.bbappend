DEPENDS_append = " clang-native"
